# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\dfs;..\..\components\dfs\include;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;.\FatFS_R0.10;.\Thread;.\menuSys;.\UserDevices;.\Route;.\Auto;.\GeneralFunctions;..\lib;.\fxh_bool;.\zx_speed
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: application.c startup.c
    ./applications/: mb.c mq.c
  group Thread
    ./Thread/: t_lcd_refresh.c t_keyboard.c t_emergency.c t_handle.c t_FATfs.c t_timer.h t_timer.c t_realspe.c
    ./: Y_handle.c Y_handle.h
  group menu
    ./menuSys/: m_func.c m_list.c m_sys.c m_test.c m_route.c m_cock.c m_cock.h liwenlin.c liwenlin.h
  group UserDevices
    ./UserDevices/: lcd_keyboard.c mecanum.c gyro.c encoder.c gps.c relay.c motor.c camera.c laser.c lightboard.c sonic.c
    ./: Swedish.c Swedish.h
  group Route
    ./Route/: easyline.c goline.c gocircle.c keep.c pointpath.c PointRoute.c
  group Auto
    ./Auto/: t_auto.c t_arm.c goroute.c armaction.c t_catching.h t_catching.c
  group GeneralFunction
    ./GeneralFunctions/: mymath.c mystring.c pid.c databack.c
  group Drivers
    drivers/: board.c serial.c usart.c stm32f4xx_it.c
    ./drivers/: dma.c dma_rx_isr.c stm324xg_eval_sdio_sd.c io.c pwm.c can.c can_database.c Command.c fan.c sd_serve.c sd_save.c tim.c mouse.c mouse.h
  group fxh_bool
    ./fxh_bool/: can_send.c fxh_misc.c laser1.c lightboard1.c pid1.c sonic1.c t_test.c hook.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../lib/: finsh_lib.lib
  group FatFS
    ./FatFS_R0.10/: diskio.c ff.c
    ./FatFS_R0.10/option/: cc936.c
  group readme
    ./: readme.txt
  group zx_speed
    ./zx_speed/: speed_test.c
